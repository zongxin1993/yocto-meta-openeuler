PV = "1.1.6"
SRC_URL = "file://mtdev-${PV}.tar.bz2"
