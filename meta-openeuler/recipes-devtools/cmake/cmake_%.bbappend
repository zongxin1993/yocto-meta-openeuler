# main bbfile: yocto-poky/meta/recipes-devtools/cmake/cmake_3.19.5.bb
require cmake-openeuler.inc
