PV = "3.20.0"
require pypi-src-openeuler.inc

BBCLASSEXTEND = "native"
