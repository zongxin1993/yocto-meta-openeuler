SRC_URI_append_libc-musl = " \
                           file://libmetal-delete-librt-hugetlbfs.patch \
"

