# add CXXFLAGS to support musl
CXXFLAGS_libc-musl += "-std=gnu++98"
