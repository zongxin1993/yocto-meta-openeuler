# source bb file meta-openeuler/recipes-mcs/libmetal/libmetal_2022.04.0.bb

OPENEULER_BRANCH = "openEuler-23.03"

PV = "2022.10.0"
