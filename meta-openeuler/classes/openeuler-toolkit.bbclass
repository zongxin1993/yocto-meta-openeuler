# the tool usage on the yocto-embedded-tools
DEPENDS_append_class-target = " openeuler-toolkit-native"
