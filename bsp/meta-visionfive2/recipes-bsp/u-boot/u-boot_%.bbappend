SRCREV = "d80bb749fab53da72c4a0e09b8c2d2aaa3103c91"

SRC_URI = "git://git.denx.de/u-boot.git;branch=master \
          "
