RDEPENDS_${PN}_remove_starfive-dubhe += "kernel-img \
"

