RDEPENDS:packagegroup-base:append = " \
e2fsprogs-resize2fs \
"

RDEPENDS:packagegroup-base:append:hieulerpi1 = " \
hieulerpi1-bsp-pkg \
"
